# Keil uVision project Blinky.uvprojx, settings and files
target STM32L476 Flash (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Files
    ./: Blinky.c stdout_USART.c
  group Documentation
    ./: Abstract.txt
target STM32L476 RAM (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: as above
  output: Blinky
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS:CORE 5.5.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.3.1
